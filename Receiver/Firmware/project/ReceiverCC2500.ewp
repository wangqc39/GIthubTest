# IAR project ReceiverCC2500.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: T:\OneDrive\RemotControl\CC2500\SHFSS\Receiver\Firmware\Application; T:\OneDrive\RemotControl\CC2500\SHFSS\Receiver\Firmware\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ReceiverCC2500.bin
  ILINK.IlinkOutputFile: ReceiverCC2500.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../Application/: PwmOut.c
  group App
    ../Application/: CC2500.c CC2500.h key.c Led.c main.c main.h Shfss.c Shfss.h stm8s_conf.h stm8s_it.c stm8s_it.h Timer.c Timer.h
  group Lib
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
